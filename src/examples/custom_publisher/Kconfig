## src/modules/for_Test_use/Kconfig
```kconfig
menuconfig TEMPLATES_TEMPLATE_MODULE_1
	bool "template_module_2"
	default n
	---help---
		Enable support for template_module
```
